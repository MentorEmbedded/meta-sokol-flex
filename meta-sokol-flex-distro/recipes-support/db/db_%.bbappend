# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------------------------------------------------

SRC_URI:sokol-flex = "git://github.com/MentorEmbedded/libdb;branch=5.3;protocol=https"
SRCREV:sokol-flex = "81e5dd637b0bd954904130a2a493d3ac281148dc"
PV:sokol-flex = "5.3.28+git${SRCPV}"
S:sokol-flex = "${WORKDIR}/git"
