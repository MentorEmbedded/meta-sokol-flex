# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------------------------------------------------

FLEX_LVM_PKG = ""
FLEX_LVM_PKG:sokol-flex = "lvm2-flex.inc"

include ${FLEX_LVM_PKG}
