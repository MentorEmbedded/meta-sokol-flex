# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------------------------------------------------

EXTRA_OECONF:append:class-native:sokol-flex = " --disable-schedutils"
