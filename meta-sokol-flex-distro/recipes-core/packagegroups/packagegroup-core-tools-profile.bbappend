# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------------------------------------------------

# Sokol Flex OS Flex does not support systemtap. Systemtap brings boost which takes lots of resources. So we do not need it.
SYSTEMTAP:sokol-flex = ""
