# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------------------------------------------------

EXTRA_OECONF:append:class-native:innexis-linux = " --disable-schedutils"
