# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------------------------------------------------

SRC_URI:innexis-linux = "git://github.com/MentorEmbedded/libdb;branch=5.3;protocol=https"
SRCREV:innexis-linux = "81e5dd637b0bd954904130a2a493d3ac281148dc"
PV:innexis-linux = "5.3.28+git${SRCPV}"
S:innexis-linux = "${WORKDIR}/git"
