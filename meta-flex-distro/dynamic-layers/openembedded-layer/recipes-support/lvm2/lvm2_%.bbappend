# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------------------------------------------------

FLEX_LVM_PKG = ""
FLEX_LVM_PKG:flex-os = "lvm2-flex.inc"

require ${FLEX_LVM_PKG}
