# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------------------------------------------------

KERNEL_FEATURES:append:innexis-linux = " cfg/fs/ext4.scc"
