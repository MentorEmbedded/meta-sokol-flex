# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: GPL-2.0
# ---------------------------------------------------------------------------------------------------------------------

RDEPENDS:finch:append:feature-sokol-flex-staging = " python3-core"
