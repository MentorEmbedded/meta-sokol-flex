# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------------------------------------------------

DEPENDS:append:feature-sokol-flex-staging = " flex-native"
