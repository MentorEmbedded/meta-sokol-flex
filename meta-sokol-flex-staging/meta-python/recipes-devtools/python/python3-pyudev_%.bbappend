# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------------------------------------------------

RDEPENDS:${PN}:append:feature-sokol-flex-staging = "\
    ${PYTHON_PN}-fcntl \
"
