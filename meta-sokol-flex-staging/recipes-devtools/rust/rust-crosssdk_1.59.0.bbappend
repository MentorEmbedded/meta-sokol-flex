# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------------------------------------------------

PN:feature-sokol-flex-staging = "rust-crosssdk-${SDK_ARCH}-${RUST_LIBC}"
