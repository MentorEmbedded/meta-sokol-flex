# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------------------------------------------------

RDEPENDS:${PN}:append:feature-sokol-flex-staging = " perl-module-list-util perl-module-bignum"
