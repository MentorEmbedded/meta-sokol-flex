# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------------------------------------------------

RDEPENDS:${PN}:append:feature-flex-staging = " \
    perl-module-autoloader \
"
