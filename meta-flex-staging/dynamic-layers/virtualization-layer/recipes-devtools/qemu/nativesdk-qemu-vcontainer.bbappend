PV := "11.1.0"

# Point to this layers qemu files directory for patches and support files
FILESEXTRAPATHS:prepend := "${LAYERDIR_flex-staging}/recipes-devtools/qemu/qemu:"
