# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------------------------------------------------

RDEPENDS:${PN}:append:feature-flex-staging = " ${PYTHON_PN}-distutils"
