# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: GPL-2.0
# ---------------------------------------------------------------------------------------------------------------------

RDEPENDS:finch:append:feature-flex-staging = " python3-core"
ALLOW_EMPTY:${PN} = "1"
