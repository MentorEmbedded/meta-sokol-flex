FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://Fix-arm64-advanced-prefetcher.patch"
