# ---------------------------------------------------------------------------------------------------------------------
# SPDX-License-Identifier: MIT
# ---------------------------------------------------------------------------------------------------------------------

EXTRA_OECONF:append:feature-flex-staging = " \
    --with-ca-path=${sysconfdir}/ssl/certs \
"
